# Keil uVision project F405RGT6_Demo.uvprojx, settings and files
target F405RGT6_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F405RGT6_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER, ARM_MATH_CM4
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\MYLIB;..\MYTASK;.\SystemConfig;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\TSET_FUNC;..\SEGGER_RTT_V784\Config;..\SEGGER_RTT_V784\Examples;..\SEGGER_RTT_V784\RTT;..\SEGGER_RTT_V784\Syscalls
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ./SystemConfig/: stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
    ../MYLIB/: config.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c
  group MYLIB
    ../MYLIB/: nvic.c led.c laser.c uart.c can.c pid.c tim.c crc.c motor.c friction.c zerocheck.c communicate.c FeedForward.c iwdg.c FeedForward.h
  group MYTASK
    ../MYTASK/: start_task.c selfcheck_task.c gimbal_task.c shoot_task.c debug_task.c judge_task.c GraphicsSendTask.c ActionControl_task.c CPU_Task.c
  group RTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group RTOS_PTAB
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group TEST_FUNC
    ../TSET_FUNC/: counter.c debug.c os_tick.c tools.c
  group SEGGER_RTT_V784
    ../SEGGER_RTT_V784/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:DSP 1.5.1
