# Keil uVision project F405RGT6_Demo.uvprojx, settings and files
target F405RGT6_Demo (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F405RGT6_Demo +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\FWLIB\inc;..\MYLIB;..\MYTASK;.\SystemConfig;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
    ./SystemConfig/: stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
    ../MYLIB/: config.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c
  group MYLIB
    ../MYLIB/: nvic.c led.c laser.c uart.c can.c pid.c tim.c crc.c motor.c friction.c zerocheck.c communicate.c trajectory.c iwdg.c
  group MYTASK
    ../MYTASK/: start_task.c selfcheck_task.c gimbal_task.c shoot_task.c debug_task.c judge_task.c
  group RTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group RTOS_PTAB
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
